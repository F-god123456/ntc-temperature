# Keil uVision project BY_STM32F030K6_Board_Lib.uvprojx, settings and files
target STM32F030K6_USART1_SendRevic_Interrupt (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BY_STM32F030K6_Board_Lib +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\ARM;..\CORE;..\HARDWARE;..\SYSTEM;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ARM
    ../ARM/: startup_stm32f030.s
  group CORE
    ../CORE/: stm32f0xx_it.c system_stm32f0xx.c
  group User
    ./: main.c
    ../HARDWARE/: user_adc.c
  group SYSTEM
    ../SYSTEM/: delay.c USART1.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
